# Keil uVision project LoRaMac.uvproj, settings and files
target LoRaMac-433 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRaMac
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_433 USE_USB_CDC
  c include: ..\..\..\..\src;..\..\..\..\src\boards\RFM95W-BB;..\..\..\..\src\boards\RFM95W-BB\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto;..\..\..\..\src\boards\mcu\stm32\STM32_USB-FS-Device_Driver\inc;..\..\..\..\src\boards\RFM95W-BB\usb\cdc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group apps
    ../../../../src/apps/LoRaMac/classC/RFM95W-BB/: main.c
  group boards\RFM95W-BB
    ../../../../src/boards/RFM95W-BB/: uart-usb-board.c usb-cdc-board.c adc-board.c board.c gpio-board.c gps-board.c rtc-board.c spi-board.c sx1276-board.c timer-board.c uart-board.c
  group boards\RFM95W-BB\cmsis
    ../../../../src/boards/RFM95W-BB/cmsis/arm-std/: startup_stm32l1xx_md.s
    ../../../../src/boards/RFM95W-BB/cmsis/: system_stm32l1xx.c
  group boards\RFM95W-BB\usb\cdc
    ../../../../src/boards/RFM95W-BB/usb/cdc/src/: usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group boards\mcu\STM32L1xx_StdPeriph_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group boards\mcu\STM32_USB-FS-Device_Driver
    ../../../../src/boards/mcu/stm32/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group radio
    ../../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c timer.c uart.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c RC5.c
target LoRaMac-433-Bootloader (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRaMac
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_433 USE_BOOTLOADER
  c include: ..\..\..\..\src;..\..\..\..\src\boards\SensorNode;..\..\..\..\src\boards\SensorNode\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x2800
target LoRaMac-470 (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_470
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target LoRaMac-470-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_470 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target LoRaMac-868 (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_868
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target LoRaMac-868-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_868 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target LoRaMac-915 (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_915
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target LoRaMac-915-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_915 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
